v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Generated by scripts/gen_allcells_sch.py from ROWS in scripts/mag_build_allcells.tcl; do not edit by hand.} 0 -200 0 0 0.4 0.4 {}
C {sky130_efx_lvdig__inv_1.sym} 0 0 0 0 {name=xinv_1 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} -40 0 0 0 {name=l1 lab=xinv_1_A}
C {devices/lab_pin.sym} 40 0 0 1 {name=l2 lab=xinv_1_Y}
C {sky130_efx_lvdig__inv_2.sym} 360 0 0 0 {name=xinv_2 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 320 0 0 0 {name=l3 lab=xinv_2_A}
C {devices/lab_pin.sym} 400 0 0 1 {name=l4 lab=xinv_2_Y}
C {sky130_efx_lvdig__inv_4.sym} 720 0 0 0 {name=xinv_4 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 680 0 0 0 {name=l5 lab=xinv_4_A}
C {devices/lab_pin.sym} 760 0 0 1 {name=l6 lab=xinv_4_Y}
C {sky130_efx_lvdig__nand2_1.sym} 1080 0 0 0 {name=xnand2_1 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 1020 -20 0 0 {name=l7 lab=xnand2_1_A}
C {devices/lab_pin.sym} 1020 20 0 0 {name=l8 lab=xnand2_1_B}
C {devices/lab_pin.sym} 1140 0 0 1 {name=l9 lab=xnand2_1_Y}
C {sky130_efx_lvdig__nor2_1.sym} 1440 0 0 0 {name=xnor2_1 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 1380 -20 0 0 {name=l10 lab=xnor2_1_A}
C {devices/lab_pin.sym} 1380 20 0 0 {name=l11 lab=xnor2_1_B}
C {devices/lab_pin.sym} 1500 0 0 1 {name=l12 lab=xnor2_1_Y}
C {sky130_efx_lvdig__nand2_2.sym} 1800 0 0 0 {name=xnand2_2 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 1740 -20 0 0 {name=l13 lab=xnand2_2_A}
C {devices/lab_pin.sym} 1740 20 0 0 {name=l14 lab=xnand2_2_B}
C {devices/lab_pin.sym} 1860 0 0 1 {name=l15 lab=xnand2_2_Y}
C {sky130_efx_lvdig__nor2_2.sym} 2160 0 0 0 {name=xnor2_2 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 2100 -20 0 0 {name=l16 lab=xnor2_2_A}
C {devices/lab_pin.sym} 2100 20 0 0 {name=l17 lab=xnor2_2_B}
C {devices/lab_pin.sym} 2220 0 0 1 {name=l18 lab=xnor2_2_Y}
C {sky130_efx_lvdig__buf_1.sym} 2520 0 0 0 {name=xbuf_1 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 2480 0 0 0 {name=l19 lab=xbuf_1_A}
C {devices/lab_pin.sym} 2560 0 0 1 {name=l20 lab=xbuf_1_X}
C {sky130_efx_lvdig__buf_2.sym} 0 400 0 0 {name=xbuf_2 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} -40 400 0 0 {name=l21 lab=xbuf_2_A}
C {devices/lab_pin.sym} 40 400 0 1 {name=l22 lab=xbuf_2_X}
C {sky130_efx_lvdig__buf_4.sym} 360 400 0 0 {name=xbuf_4 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 320 400 0 0 {name=l23 lab=xbuf_4_A}
C {devices/lab_pin.sym} 400 400 0 1 {name=l24 lab=xbuf_4_X}
C {sky130_efx_lvdig__clkinv_1.sym} 720 400 0 0 {name=xclkinv_1 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 680 400 0 0 {name=l25 lab=xclkinv_1_A}
C {devices/lab_pin.sym} 760 400 0 1 {name=l26 lab=xclkinv_1_Y}
C {sky130_efx_lvdig__clkinv_2.sym} 1080 400 0 0 {name=xclkinv_2 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 1040 400 0 0 {name=l27 lab=xclkinv_2_A}
C {devices/lab_pin.sym} 1120 400 0 1 {name=l28 lab=xclkinv_2_Y}
C {sky130_efx_lvdig__nor3_2.sym} 1440 400 0 0 {name=xnor3_2 VGND=VGND VNB=VGND VPB=VPWR_R01 VPWR=VPWR_R01}
C {devices/lab_pin.sym} 1380 360 0 0 {name=l29 lab=xnor3_2_A}
C {devices/lab_pin.sym} 1380 400 0 0 {name=l30 lab=xnor3_2_B}
C {devices/lab_pin.sym} 1380 440 0 0 {name=l31 lab=xnor3_2_C}
C {devices/lab_pin.sym} 1500 400 0 1 {name=l32 lab=xnor3_2_Y}
C {sky130_efx_lvdig__clkinv_4.sym} 0 800 0 0 {name=xclkinv_4 VGND=VGND VNB=VGND VPB=VPWR_R23 VPWR=VPWR_R23}
C {devices/lab_pin.sym} -40 800 0 0 {name=l33 lab=xclkinv_4_A}
C {devices/lab_pin.sym} 40 800 0 1 {name=l34 lab=xclkinv_4_Y}
C {sky130_efx_lvdig__clkinv_8.sym} 360 800 0 0 {name=xclkinv_8 VGND=VGND VNB=VGND VPB=VPWR_R23 VPWR=VPWR_R23}
C {devices/lab_pin.sym} 320 800 0 0 {name=l35 lab=xclkinv_8_A}
C {devices/lab_pin.sym} 400 800 0 1 {name=l36 lab=xclkinv_8_Y}
C {sky130_efx_lvdig__clkbuf_1.sym} 720 800 0 0 {name=xclkbuf_1 VGND=VGND VNB=VGND VPB=VPWR_R23 VPWR=VPWR_R23}
C {devices/lab_pin.sym} 680 800 0 0 {name=l37 lab=xclkbuf_1_A}
C {devices/lab_pin.sym} 760 800 0 1 {name=l38 lab=xclkbuf_1_X}
C {sky130_efx_lvdig__and2_1.sym} 1080 800 0 0 {name=xand2_1 VGND=VGND VNB=VGND VPB=VPWR_R23 VPWR=VPWR_R23}
C {devices/lab_pin.sym} 1020 780 0 0 {name=l39 lab=xand2_1_A}
C {devices/lab_pin.sym} 1020 820 0 0 {name=l40 lab=xand2_1_B}
C {devices/lab_pin.sym} 1140 800 0 1 {name=l41 lab=xand2_1_X}
C {sky130_efx_lvdig__and2_2.sym} 1440 800 0 0 {name=xand2_2 VGND=VGND VNB=VGND VPB=VPWR_R23 VPWR=VPWR_R23}
C {devices/lab_pin.sym} 1380 780 0 0 {name=l42 lab=xand2_2_A}
C {devices/lab_pin.sym} 1380 820 0 0 {name=l43 lab=xand2_2_B}
C {devices/lab_pin.sym} 1500 800 0 1 {name=l44 lab=xand2_2_X}
C {sky130_efx_lvdig__clkbuf_2.sym} 0 1200 0 0 {name=xclkbuf_2 VGND=VGND VNB=VGND VPB=VPWR_R23 VPWR=VPWR_R23}
C {devices/lab_pin.sym} -40 1200 0 0 {name=l45 lab=xclkbuf_2_A}
C {devices/lab_pin.sym} 40 1200 0 1 {name=l46 lab=xclkbuf_2_X}
C {sky130_efx_lvdig__clkbuf_4.sym} 360 1200 0 0 {name=xclkbuf_4 VGND=VGND VNB=VGND VPB=VPWR_R23 VPWR=VPWR_R23}
C {devices/lab_pin.sym} 320 1200 0 0 {name=l47 lab=xclkbuf_4_A}
C {devices/lab_pin.sym} 400 1200 0 1 {name=l48 lab=xclkbuf_4_X}
C {sky130_efx_lvdig__clkbuf_8.sym} 720 1200 0 0 {name=xclkbuf_8 VGND=VGND VNB=VGND VPB=VPWR_R23 VPWR=VPWR_R23}
C {devices/lab_pin.sym} 680 1200 0 0 {name=l49 lab=xclkbuf_8_A}
C {devices/lab_pin.sym} 760 1200 0 1 {name=l50 lab=xclkbuf_8_X}
C {sky130_efx_lvdig__and2_4.sym} 1080 1200 0 0 {name=xand2_4 VGND=VGND VNB=VGND VPB=VPWR_R23 VPWR=VPWR_R23}
C {devices/lab_pin.sym} 1020 1180 0 0 {name=l51 lab=xand2_4_A}
C {devices/lab_pin.sym} 1020 1220 0 0 {name=l52 lab=xand2_4_B}
C {devices/lab_pin.sym} 1140 1200 0 1 {name=l53 lab=xand2_4_X}
C {sky130_efx_lvdig__and3_1.sym} 0 1600 0 0 {name=xand3_1 VGND=VGND VNB=VGND VPB=VPWR_R45 VPWR=VPWR_R45}
C {devices/lab_pin.sym} -60 1560 0 0 {name=l54 lab=xand3_1_A}
C {devices/lab_pin.sym} -60 1600 0 0 {name=l55 lab=xand3_1_B}
C {devices/lab_pin.sym} -60 1640 0 0 {name=l56 lab=xand3_1_C}
C {devices/lab_pin.sym} 60 1600 0 1 {name=l57 lab=xand3_1_X}
C {sky130_efx_lvdig__and4_2.sym} 360 1600 0 0 {name=xand4_2 VGND=VGND VNB=VGND VPB=VPWR_R45 VPWR=VPWR_R45}
C {devices/lab_pin.sym} 300 1540 0 0 {name=l58 lab=xand4_2_A}
C {devices/lab_pin.sym} 300 1580 0 0 {name=l59 lab=xand4_2_B}
C {devices/lab_pin.sym} 300 1620 0 0 {name=l60 lab=xand4_2_C}
C {devices/lab_pin.sym} 300 1660 0 0 {name=l61 lab=xand4_2_D}
C {devices/lab_pin.sym} 420 1600 0 1 {name=l62 lab=xand4_2_X}
C {sky130_efx_lvdig__or2_1.sym} 720 1600 0 0 {name=xor2_1 VGND=VGND VNB=VGND VPB=VPWR_R45 VPWR=VPWR_R45}
C {devices/lab_pin.sym} 660 1580 0 0 {name=l63 lab=xor2_1_A}
C {devices/lab_pin.sym} 660 1620 0 0 {name=l64 lab=xor2_1_B}
C {devices/lab_pin.sym} 780 1600 0 1 {name=l65 lab=xor2_1_X}
C {sky130_efx_lvdig__or2_2.sym} 1080 1600 0 0 {name=xor2_2 VGND=VGND VNB=VGND VPB=VPWR_R45 VPWR=VPWR_R45}
C {devices/lab_pin.sym} 1020 1580 0 0 {name=l66 lab=xor2_2_A}
C {devices/lab_pin.sym} 1020 1620 0 0 {name=l67 lab=xor2_2_B}
C {devices/lab_pin.sym} 1140 1600 0 1 {name=l68 lab=xor2_2_X}
C {sky130_efx_lvdig__or2_4.sym} 0 2000 0 0 {name=xor2_4 VGND=VGND VNB=VGND VPB=VPWR_R45 VPWR=VPWR_R45}
C {devices/lab_pin.sym} -60 1980 0 0 {name=l69 lab=xor2_4_A}
C {devices/lab_pin.sym} -60 2020 0 0 {name=l70 lab=xor2_4_B}
C {devices/lab_pin.sym} 60 2000 0 1 {name=l71 lab=xor2_4_X}
C {sky130_efx_lvdig__or3_1.sym} 360 2000 0 0 {name=xor3_1 VGND=VGND VNB=VGND VPB=VPWR_R45 VPWR=VPWR_R45}
C {devices/lab_pin.sym} 300 1960 0 0 {name=l72 lab=xor3_1_A}
C {devices/lab_pin.sym} 300 2000 0 0 {name=l73 lab=xor3_1_B}
C {devices/lab_pin.sym} 300 2040 0 0 {name=l74 lab=xor3_1_C}
C {devices/lab_pin.sym} 420 2000 0 1 {name=l75 lab=xor3_1_X}
C {sky130_efx_lvdig__a21o_1.sym} 720 2000 0 0 {name=xa21o_1 VGND=VGND VNB=VGND VPB=VPWR_R45 VPWR=VPWR_R45}
C {devices/lab_pin.sym} 640 1960 0 0 {name=l76 lab=xa21o_1_A1}
C {devices/lab_pin.sym} 640 2000 0 0 {name=l77 lab=xa21o_1_A2}
C {devices/lab_pin.sym} 640 2040 0 0 {name=l78 lab=xa21o_1_B1}
C {devices/lab_pin.sym} 800 2000 0 1 {name=l79 lab=xa21o_1_X}
C {sky130_efx_lvdig__o21a_1.sym} 1080 2000 0 0 {name=xo21a_1 VGND=VGND VNB=VGND VPB=VPWR_R45 VPWR=VPWR_R45}
C {devices/lab_pin.sym} 1000 1960 0 0 {name=l80 lab=xo21a_1_A1}
C {devices/lab_pin.sym} 1000 2000 0 0 {name=l81 lab=xo21a_1_A2}
C {devices/lab_pin.sym} 1000 2040 0 0 {name=l82 lab=xo21a_1_B1}
C {devices/lab_pin.sym} 1160 2000 0 1 {name=l83 lab=xo21a_1_X}
C {sky130_efx_lvdig__a22o_1.sym} 1440 2000 0 0 {name=xa22o_1 VGND=VGND VNB=VGND VPB=VPWR_R45 VPWR=VPWR_R45}
C {devices/lab_pin.sym} 1360 1940 0 0 {name=l84 lab=xa22o_1_A1}
C {devices/lab_pin.sym} 1360 1980 0 0 {name=l85 lab=xa22o_1_A2}
C {devices/lab_pin.sym} 1360 2020 0 0 {name=l86 lab=xa22o_1_B1}
C {devices/lab_pin.sym} 1360 2060 0 0 {name=l87 lab=xa22o_1_B2}
C {devices/lab_pin.sym} 1520 2000 0 1 {name=l88 lab=xa22o_1_X}
C {sky130_efx_lvdig__mux2_1.sym} 0 2400 0 0 {name=xmux2_1 VGND=VGND VNB=VGND VPB=VPWR_R67 VPWR=VPWR_R67}
C {devices/lab_pin.sym} -40 2380 0 0 {name=l89 lab=xmux2_1_A0}
C {devices/lab_pin.sym} -40 2420 0 0 {name=l90 lab=xmux2_1_A1}
C {devices/lab_pin.sym} -40 2460 0 0 {name=l91 lab=xmux2_1_S}
C {devices/lab_pin.sym} 40 2400 0 1 {name=l92 lab=xmux2_1_X}
C {sky130_efx_lvdig__mux2_2.sym} 360 2400 0 0 {name=xmux2_2 VGND=VGND VNB=VGND VPB=VPWR_R67 VPWR=VPWR_R67}
C {devices/lab_pin.sym} 320 2380 0 0 {name=l93 lab=xmux2_2_A0}
C {devices/lab_pin.sym} 320 2420 0 0 {name=l94 lab=xmux2_2_A1}
C {devices/lab_pin.sym} 320 2460 0 0 {name=l95 lab=xmux2_2_S}
C {devices/lab_pin.sym} 400 2400 0 1 {name=l96 lab=xmux2_2_X}
C {sky130_efx_lvdig__ha_1.sym} 720 2400 0 0 {name=xha_1 VGND=VGND VNB=VGND VPB=VPWR_R67 VPWR=VPWR_R67}
C {devices/lab_pin.sym} 660 2360 0 0 {name=l97 lab=xha_1_A}
C {devices/lab_pin.sym} 660 2440 0 0 {name=l98 lab=xha_1_B}
C {devices/lab_pin.sym} 780 2360 0 1 {name=l99 lab=xha_1_COUT}
C {devices/lab_pin.sym} 780 2440 0 1 {name=l100 lab=xha_1_SUM}
C {sky130_efx_lvdig__dfxtp_2.sym} 0 2800 0 0 {name=xdfxtp_2 VGND=VGND VNB=VGND VPB=VPWR_R67 VPWR=VPWR_R67}
C {devices/lab_pin.sym} -90 2790 0 0 {name=l101 lab=xdfxtp_2_CLK}
C {devices/lab_pin.sym} -90 2810 0 0 {name=l102 lab=xdfxtp_2_D}
C {devices/lab_pin.sym} 90 2790 0 1 {name=l103 lab=xdfxtp_2_Q}
C {sky130_efx_lvdig__dfxbp_2.sym} 0 3200 0 0 {name=xdfxbp_2 VGND=VGND VNB=VGND VPB=VPWR_R89 VPWR=VPWR_R89}
C {devices/lab_pin.sym} -90 3190 0 0 {name=l104 lab=xdfxbp_2_CLK}
C {devices/lab_pin.sym} -90 3210 0 0 {name=l105 lab=xdfxbp_2_D}
C {devices/lab_pin.sym} 90 3190 0 1 {name=l106 lab=xdfxbp_2_Q}
C {devices/lab_pin.sym} 90 3210 0 1 {name=l107 lab=xdfxbp_2_Q_N}
C {sky130_efx_lvdig__dfrtp_1.sym} 0 3600 0 0 {name=xdfrtp_1 VGND=VGND VNB=VGND VPB=VPWR_R89 VPWR=VPWR_R89}
C {devices/lab_pin.sym} -90 3580 0 0 {name=l108 lab=xdfrtp_1_CLK}
C {devices/lab_pin.sym} -90 3600 0 0 {name=l109 lab=xdfrtp_1_D}
C {devices/lab_pin.sym} -90 3620 0 0 {name=l110 lab=xdfrtp_1_RESET_B}
C {devices/lab_pin.sym} 90 3580 0 1 {name=l111 lab=xdfrtp_1_Q}
C {sky130_efx_lvdig__dfrtp_2.sym} 0 4000 0 0 {name=xdfrtp_2 VGND=VGND VNB=VGND VPB=VPWR_R1011 VPWR=VPWR_R1011}
C {devices/lab_pin.sym} -90 3980 0 0 {name=l112 lab=xdfrtp_2_CLK}
C {devices/lab_pin.sym} -90 4000 0 0 {name=l113 lab=xdfrtp_2_D}
C {devices/lab_pin.sym} -90 4020 0 0 {name=l114 lab=xdfrtp_2_RESET_B}
C {devices/lab_pin.sym} 90 3980 0 1 {name=l115 lab=xdfrtp_2_Q}
C {sky130_efx_lvdig__dfrbp_1.sym} 0 4400 0 0 {name=xdfrbp_1 VGND=VGND VNB=VGND VPB=VPWR_R1011 VPWR=VPWR_R1011}
C {devices/lab_pin.sym} -90 4380 0 0 {name=l116 lab=xdfrbp_1_CLK}
C {devices/lab_pin.sym} -90 4400 0 0 {name=l117 lab=xdfrbp_1_D}
C {devices/lab_pin.sym} -90 4420 0 0 {name=l118 lab=xdfrbp_1_RESET_B}
C {devices/lab_pin.sym} 90 4380 0 1 {name=l119 lab=xdfrbp_1_Q}
C {devices/lab_pin.sym} 90 4400 0 1 {name=l120 lab=xdfrbp_1_Q_N}
C {sky130_efx_lvdig__dfrbp_2.sym} 0 4800 0 0 {name=xdfrbp_2 VGND=VGND VNB=VGND VPB=VPWR_R1213 VPWR=VPWR_R1213}
C {devices/lab_pin.sym} -90 4780 0 0 {name=l121 lab=xdfrbp_2_CLK}
C {devices/lab_pin.sym} -90 4800 0 0 {name=l122 lab=xdfrbp_2_D}
C {devices/lab_pin.sym} -90 4820 0 0 {name=l123 lab=xdfrbp_2_RESET_B}
C {devices/lab_pin.sym} 90 4780 0 1 {name=l124 lab=xdfrbp_2_Q}
C {devices/lab_pin.sym} 90 4800 0 1 {name=l125 lab=xdfrbp_2_Q_N}
C {sky130_efx_lvdig__dfstp_1.sym} 0 5200 0 0 {name=xdfstp_1 VGND=VGND VNB=VGND VPB=VPWR_R1213 VPWR=VPWR_R1213}
C {devices/lab_pin.sym} -90 5180 0 0 {name=l126 lab=xdfstp_1_CLK}
C {devices/lab_pin.sym} -90 5200 0 0 {name=l127 lab=xdfstp_1_D}
C {devices/lab_pin.sym} -90 5220 0 0 {name=l128 lab=xdfstp_1_SET_B}
C {devices/lab_pin.sym} 90 5180 0 1 {name=l129 lab=xdfstp_1_Q}
C {sky130_efx_lvdig__dfstp_2.sym} 0 5600 0 0 {name=xdfstp_2 VGND=VGND VNB=VGND VPB=VPWR_R1415 VPWR=VPWR_R1415}
C {devices/lab_pin.sym} -90 5580 0 0 {name=l130 lab=xdfstp_2_CLK}
C {devices/lab_pin.sym} -90 5600 0 0 {name=l131 lab=xdfstp_2_D}
C {devices/lab_pin.sym} -90 5620 0 0 {name=l132 lab=xdfstp_2_SET_B}
C {devices/lab_pin.sym} 90 5580 0 1 {name=l133 lab=xdfstp_2_Q}
C {sky130_efx_lvdig__dfbbp_1.sym} 0 6000 0 0 {name=xdfbbp_1 VGND=VGND VNB=VGND VPB=VPWR_R1415 VPWR=VPWR_R1415}
C {devices/lab_pin.sym} -90 5970 0 0 {name=l134 lab=xdfbbp_1_CLK}
C {devices/lab_pin.sym} -90 5990 0 0 {name=l135 lab=xdfbbp_1_D}
C {devices/lab_pin.sym} -90 6010 0 0 {name=l136 lab=xdfbbp_1_RESET_B}
C {devices/lab_pin.sym} -90 6030 0 0 {name=l137 lab=xdfbbp_1_SET_B}
C {devices/lab_pin.sym} 90 5970 0 1 {name=l138 lab=xdfbbp_1_Q}
C {devices/lab_pin.sym} 90 5990 0 1 {name=l139 lab=xdfbbp_1_Q_N}
C {sky130_efx_lvdig__edfxtp_1.sym} 0 6400 0 0 {name=xedfxtp_1 VGND=VGND VNB=VGND VPB=VPWR_R1617 VPWR=VPWR_R1617}
C {devices/lab_pin.sym} -90 6380 0 0 {name=l140 lab=xedfxtp_1_CLK}
C {devices/lab_pin.sym} -90 6400 0 0 {name=l141 lab=xedfxtp_1_D}
C {devices/lab_pin.sym} -90 6420 0 0 {name=l142 lab=xedfxtp_1_DE}
C {devices/lab_pin.sym} 90 6380 0 1 {name=l143 lab=xedfxtp_1_Q}
C {sky130_efx_lvdig__edfxbp_1.sym} 0 6800 0 0 {name=xedfxbp_1 VGND=VGND VNB=VGND VPB=VPWR_R1617 VPWR=VPWR_R1617}
C {devices/lab_pin.sym} -90 6780 0 0 {name=l144 lab=xedfxbp_1_CLK}
C {devices/lab_pin.sym} -90 6800 0 0 {name=l145 lab=xedfxbp_1_D}
C {devices/lab_pin.sym} -90 6820 0 0 {name=l146 lab=xedfxbp_1_DE}
C {devices/lab_pin.sym} 90 6780 0 1 {name=l147 lab=xedfxbp_1_Q}
C {devices/lab_pin.sym} 90 6800 0 1 {name=l148 lab=xedfxbp_1_Q_N}
C {sky130_efx_lvdig__conb_1.sym} 0 7200 0 0 {name=xconb_1 VGND=VGND VNB=VGND VPB=VPWR_R1819 VPWR=VPWR_R1819}
C {devices/lab_pin.sym} 60 7180 0 1 {name=l149 lab=xconb_1_HI}
C {devices/lab_pin.sym} 60 7220 0 1 {name=l150 lab=xconb_1_LO}
C {sky130_efx_lvdig__dlygate4sd3_1.sym} 360 7200 0 0 {name=xdlygate4sd3_1 VGND=VGND VNB=VGND VPB=VPWR_R1819 VPWR=VPWR_R1819}
C {devices/lab_pin.sym} 320 7200 0 0 {name=l151 lab=xdlygate4sd3_1_A}
C {devices/lab_pin.sym} 400 7200 0 1 {name=l152 lab=xdlygate4sd3_1_X}
C {sky130_efx_lvdig__clkdlybuf4s50_1.sym} 720 7200 0 0 {name=xclkdlybuf4s50_1 VGND=VGND VNB=VGND VPB=VPWR_R1819 VPWR=VPWR_R1819}
C {devices/lab_pin.sym} 680 7200 0 0 {name=l153 lab=xclkdlybuf4s50_1_A}
C {devices/lab_pin.sym} 760 7200 0 1 {name=l154 lab=xclkdlybuf4s50_1_X}
C {sky130_efx_lvdig__decap10.sym} 1080 7200 0 0 {name=xdecap10 VGND=VGND VNB=VGND VPB=VPWR_R1819 VPWR=VPWR_R1819}
C {sky130_efx_lvdig__decap20.sym} 1440 7200 0 0 {name=xdecap20 VGND=VGND VNB=VGND VPB=VPWR_R1819 VPWR=VPWR_R1819}
C {devices/iopin.sym} -200 0 0 0 {name=p1 lab=VGND}
C {devices/iopin.sym} -200 40 0 0 {name=p2 lab=VPWR_R01}
C {devices/iopin.sym} -200 80 0 0 {name=p3 lab=VPWR_R23}
C {devices/iopin.sym} -200 120 0 0 {name=p4 lab=VPWR_R45}
C {devices/iopin.sym} -200 160 0 0 {name=p5 lab=VPWR_R67}
C {devices/iopin.sym} -200 200 0 0 {name=p6 lab=VPWR_R89}
C {devices/iopin.sym} -200 240 0 0 {name=p7 lab=VPWR_R1011}
C {devices/iopin.sym} -200 280 0 0 {name=p8 lab=VPWR_R1213}
C {devices/iopin.sym} -200 320 0 0 {name=p9 lab=VPWR_R1415}
C {devices/iopin.sym} -200 360 0 0 {name=p10 lab=VPWR_R1617}
C {devices/iopin.sym} -200 400 0 0 {name=p11 lab=VPWR_R1819}
C {copyright.sym} -200 -200 0 0 {name=s1 place=header value="* Copyright (c) 2026 Eric Fogleman
* SPDX-License-Identifier: Apache-2.0
* Derived from SkyWater sky130_fd_sc_hd (Apache-2.0); see NOTICE"}
C {devices/code_shown.sym} -200 -400 0 0 {name=s2 only_toplevel=false place=header format="tcleval( @value )" value=".include $::LVDIG_CDL/sky130_efx_lvdig.cdl"}
